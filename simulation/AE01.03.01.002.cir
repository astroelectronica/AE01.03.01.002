.title KiCad schematic
.include "models/AL8805.spice.txt"
.include "models/B260A.spice.txt"
.include "models/BZX84C4V7.spice.txt"
.include "models/C2012CH2W101J060AA_p.mod"
.include "models/C2012X5R1H475K125AB_p.mod"
.include "models/C2012X7R2A104K125AE_p.mod"
.include "models/C2012X7R2E103K125AA_p.mod"
.include "models/C3225X7T2J104M160AC_p.mod"
.include "models/TLC2272.LIB"
.include "models/XPE_SPICE.lib"
.include "models/ZXCT1080.spice.txt"
XU103 /SW 0 /CTRL /A VCC AL8805
R103 /CTRL /PWM 1k
XU102 VCC 0 C2012X7R2A104K125AE_p
XU101 VCC 0 C2012X5R1H475K125AB_p
XU105 /A /K C3225X7T2J104M160AC_p
L101 /SW /K 68u rser=0.089
R101 VCC /A {Rs1}
D101 /SW VCC DI_B260A
V101 VCC 0 {VCC}
R102 VCC /A {Rs2}
V102 /PWM 0 PULSE(0 5 {delay} {trise} {tfall} {duty} {cycle})
XU110 0 +5V VCC /SN /VOCM ZXCT1080
XU107 /FILTER /GAIN_LOOP +5V 0 /CURRENT_FEEDBACK TLC2272
R105 /FILTER /VOCM 100
XU111 /FILTER 0 C2012X7R2E103K125AA_p
R104 /CURRENT_FEEDBACK /GAIN_LOOP 10k
R106 /GAIN_LOOP 0 10k
XU109 0 /CURRENT_FEEDBACK DI_BZX84C4V7
V103 +5V 0 5
XU108 +5V 0 C2012X7R2A104K125AE_p
XU104 +5V 0 C2012X7R2A104K125AE_p
XU106 VCC /SN C2012CH2W101J060AA_p
R107 /SN /A 10k
D201 /A /LOAD/1 XLampXPEwhite
D202 /LOAD/1 /LOAD/2 XLampXPEwhite
D203 /LOAD/2 /LOAD/3 XLampXPEwhite
D204 /LOAD/3 /LOAD/4 XLampXPEwhite
D205 /LOAD/4 /LOAD/5 XLampXPEwhite
D206 /LOAD/5 /LOAD/6 XLampXPEwhite
D208 /LOAD/7 /K XLampXPEwhite
D207 /LOAD/6 /LOAD/7 XLampXPEwhite
D209 /A /LOAD/1 XLampXPEwhite
D210 /LOAD/1 /LOAD/2 XLampXPEwhite
D211 /LOAD/2 /LOAD/3 XLampXPEwhite
D212 /LOAD/3 /LOAD/4 XLampXPEwhite
D213 /LOAD/4 /LOAD/5 XLampXPEwhite
D214 /LOAD/5 /LOAD/6 XLampXPEwhite
D216 /LOAD/7 /K XLampXPEwhite
D215 /LOAD/6 /LOAD/7 XLampXPEwhite
.end
